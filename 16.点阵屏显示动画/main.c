#include <REGX52.H>
#include "Delay.h"
#include "MatrixLED.h"

unsigned char code AniMation[]=
{
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
	0xFF,0x88,0x88,0x88,0x88,0x00,0xFE,0x01,
	0x01,0x01,0x01,0xFE,0x00,0x18,0x7E,0xC3,
	0x81,0x81,0x81,0x00,0xFF,0x18,0x24,0x42,
	0x81,0x00,0x00,0x00,0x00,0x00,0x00,0xC0,
	0x20,0x10,0x0F,0x10,0x20,0xC0,0x00,0x00,
	0x3C,0x42,0x81,0x81,0x81,0x42,0x3C,0x00,
	0x00,0xFC,0x02,0x01,0x01,0x01,0x02,0xFC,
	0x00,0x00,0x00,0x00,0xFD,0x00,0x00,0x00,
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,

};	

void main()
{	
	
	unsigned char i,offset=0,count=0;
	MatrixLED_Init();	
	while(1)
	{
		for(i=0;i<64;i++)
		{
			MatrixLED_ShowColumn(AniMation[i+offset],i);
		}
		count++;
		if(count>1)
		{
			count=0;
			offset++;
			if(offset>64)
				offset=0;
			
		}
       
	}
}

